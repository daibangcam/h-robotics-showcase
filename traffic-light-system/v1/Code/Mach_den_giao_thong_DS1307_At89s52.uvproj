# Keil uVision project Mach_den_giao_thong_DS1307_At89s52.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: Mach_den_giao_thong_DS1307_At89s52 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Mach_den_giao_thong_DS1307_At89s52.c
